Properties of the parts of a building model (IFC4)

# File
Description: IFC4
File name: Soft Top S-089.IFC
Time: 2019-06-24T14:45:59
Written by: SwIFC
Made in: SolidWorks 2019

# IfcSite, Default Site
RefLatitude: 0, 0, 0, 0; RefLongitude: 0, 0, 0, 0; RefElevation: 0 m

# IfcBuildingStorey, Default Storey
In: Default Building
Elevation: 0 m

# IfcBuildingElementProxy: Part1^Assem1
In: Default Storey
PredefinedType: ELEMENT

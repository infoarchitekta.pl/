Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView]
File name: Furniture_Tables_Kinnarps_Elsa-147EL.ifc
Time: 2021-09-30T13:32:44
Author: Supplier
Organization: BIMobject
Written by: IFC Engine DLL 2017-09-06
Made in: BIMobject-Lena
Authorization: Full Scope

# IfcBuildingStorey
Elevation: 0 m

# IfcFurnishingElement: Elsa 147EL
ePset_BIMobjectScript - Height: 724 mm; LOD: 300
ePset_BIMobject_BO - ProductName (BO_prodinfo): Elsa 147EL; SKU (BO_prodsku): elsa-147el724; ManufacturName (BO_Manufac): Kinnarps; BrandUrl (BO_brandurl): http://www.kinnarps.com/; ProductFamily (BO_prodfam): Elsa; ProductGroup (BO_prodgroup): Elsa; EditionNumber (BO_edinum): 1; Width (BO_width): 0; Height (BO_height): 0; Depth (BO_depth): 0; Weight (BO_weight): 0; QR (BO_boqrurl): http://bimobject.com/kinnarps/product/elsa-147el724; ProductDataUrl (BO_prodaturl): bimobject.com/kinnarps/product/elsa-147el724; ProductUrl (BO_producturl): https://www.kinnarps.com/products/desks--tables/training-tables/elsa/; BimObjectMainCategory (BO_bomaincat): Furniture; BimObjectMainCategoryCode (BO_bomaincat_code): furniture; BimObjectCategory (BO_bocat): Tables; BimObjectCategoryCode (BO_bocat_code): tables; IfcClassification (BO_ifcclas): Furniture; OmniClassCode (BO_omniclass_code): 23-21 25 11 13; OmniClassDescription (BO_omniclass_name): Classroom Furniture; RegionEurope (BO_europe): All; RegionNorthAmerica (BO_northamerica): All; RegionSouthAmerica (BO_southamerica): All; RegionMiddleEast (BO_middleeast): All; RegionAsia (BO_asia): All; RegionOceania (BO_oceania): All; RegionAfrica (BO_africa): All; RegionAntarctica (BO_antarctica): All

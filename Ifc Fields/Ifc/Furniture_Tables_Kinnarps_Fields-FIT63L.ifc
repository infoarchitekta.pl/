Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView]
File name: Furniture_Tables_Kinnarps_Fields-FIT63L.ifc
Time: 2021-09-24T09:07:44
Author: Supplier
Organization: BIMobject
Written by: IFC Engine DLL 2017-09-06
Made in: BIMobject-Lena
Authorization: Full Scope

# IfcBuildingStorey
Elevation: 0 m

# IfcFurnishingElement: Fields FIT63L
ePset_BIMobjectScript - LOD: 300
ePset_BIMobject_BO - ProductName (BO_prodinfo): Fields FIT63L; SKU (BO_prodsku): fields-coffetablemedium-fit63l; ManufacturName (BO_Manufac): Kinnarps; BrandUrl (BO_brandurl): http://www.kinnarps.com/; ProductFamily (BO_prodfam): Fields; ProductGroup (BO_prodgroup): Fields; EditionNumber (BO_edinum): 1; Width (BO_width): 0; Height (BO_height): 0; Depth (BO_depth): 0; Weight (BO_weight): 0; QR (BO_boqrurl): http://bimobject.com/kinnarps/product/fields-coffetablemedium-fit63l; ProductDataUrl (BO_prodaturl): bimobject.com/kinnarps/product/fields-coffetablemedium-fit63l; ProductUrl (BO_producturl): https://www.kinnarps.com/products/seating/soft-seating/fields/; BimObjectMainCategory (BO_bomaincat): Furniture; BimObjectMainCategoryCode (BO_bomaincat_code): furniture; BimObjectCategory (BO_bocat): Tables; BimObjectCategoryCode (BO_bocat_code): tables; IfcClassification (BO_ifcclas): Furniture; OmniClassCode (BO_omniclass_code): 23-21 23 15; OmniClassDescription (BO_omniclass_name): Residential Tables; RegionEurope (BO_europe): All; RegionNorthAmerica (BO_northamerica): All; RegionSouthAmerica (BO_southamerica): All; RegionMiddleEast (BO_middleeast): All; RegionAsia (BO_asia): All; RegionOceania (BO_oceania): All; RegionAfrica (BO_africa): All; RegionAntarctica (BO_antarctica): All
